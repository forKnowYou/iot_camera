# Keil uVision project iot_camera.uvprojx, settings and files
target iot_camera (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: iot_camera +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_FULL_LL_DRIVER
  c include: ../Inc;E:/xiaowo/myProject/iot_camera/STM32Cube_FW_F4_V1.24.0/Drivers/STM32F4xx_HAL_Driver/Inc;E:/xiaowo/myProject/iot_camera/STM32Cube_FW_F4_V1.24.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;E:/xiaowo/myProject/iot_camera/STM32Cube_FW_F4_V1.24.0/Middlewares/Third_Party/FreeRTOS/Source/include;E:/xiaowo/myProject/iot_camera/STM32Cube_FW_F4_V1.24.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;E:/xiaowo/myProject/iot_camera/STM32Cube_FW_F4_V1.24.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;E:/xiaowo/myProject/iot_camera/STM32Cube_FW_F4_V1.24.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include;E:/xiaowo/myProject/iot_camera/STM32Cube_FW_F4_V1.24.0/Drivers/CMSIS/Include;..\App;..\App\lib;..\..\STM32Cube_FW_F4_V1.24.0\Middlewares\Third_Party\FatFs\src;..\..\STM32Cube_FW_F4_V1.24.0\Middlewares\Third_Party\FatFs\src\option;..\..\STM32Cube_FW_F4_V1.24.0\Middlewares\Third_Party\LibJPEG\include
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: gpio.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c main.cpp stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    E:/xiaowo/myProject/iot_camera/STM32Cube_FW_F4_V1.24.0/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    E:/xiaowo/myProject/iot_camera/STM32Cube_FW_F4_V1.24.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    E:/xiaowo/myProject/iot_camera/STM32Cube_FW_F4_V1.24.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    E:/xiaowo/myProject/iot_camera/STM32Cube_FW_F4_V1.24.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../STM32Cube_FW_F4_V1.24.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_spi.c stm32f4xx_ll_gpio.c stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_ll_rcc.c
  group App
    ../App/: appmain.cpp espApp.cpp ledApp.cpp
  group AppLib
    ../App/lib/: espAt.cpp gui.cpp ili9341.cpp led.cpp ov7725.cpp pin.cpp print.cpp softiic.cpp timer.cpp xpt2046.cpp dct.c tinylibjpeg.c tje.c
software components: CMSIS:CORE 5.1.1
